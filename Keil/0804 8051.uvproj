# Keil uVision project 0804 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: 0804 8051 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 8051 0804.a51
